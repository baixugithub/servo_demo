# Keil uVision project SERVO.uvproj, settings and files
target servo_demo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SERVO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\CMSIS\CoreSupport;..\..\CMSIS\STM32F10x;..\..\Hardware\inc;..\..\Libraries\inc;..\..\system\inc;..\..\user\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../../user/src/: main.c stm32f10x_it.c
  group Hardware
    ../../Hardware/src/: servo.c lcd.c
  group Libraries
    ../../Libraries/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group system
    ../../system/src/: delay.c system.c usart.c
  group CMSIS
    ../../CMSIS/CoreSupport/: core_cm3.c
    ../../CMSIS/STM32F10x/: system_stm32f10x.c
  group startup
    ../../startup/arm/: startup_stm32f10x_md.s
  group Description
    ../../Description/: Description.txt
